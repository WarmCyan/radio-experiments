options:
  parameters:
    description: Simple adjustable RX monitor, with a bit more functionality
    generate_options: qt_gui
    id: fancy_fm
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 146.440e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    comment: |-
      "Wide Band FM Receiver"

      (~4:00)

      Quadrature rate = output rate of low pass filter
      (which is sample rate / decimation, or:
      2M / 4 = 500k)

      Decimation of 1 means don't change sample
      rate
    quad_rate: 500e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Cutoff freq referred to as "half bandwidth of 
      the desired channel bandwidth". Still not 
      100% clear on what this means. (~3:30)

      Transition width is how quickly the filter rolls off
      (~3:38)

      Decimation - cuts down audio sample rate?
      (~3:45)

      This means the output rate due to decimation 
      will be 2M / 4 = 500k
    cutoff_freq: 100e3
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      A video describing a (roughly) similar setup 
      can be found here:
      https://www.youtube.com/watch?v=KWeY2yqwVA0

      (all times in parens are referencing the video)
    note: Video tutorial
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      This block takes the absurdly high sample rate
      and turns it into something the sound card can
      actually handle without exploding.

      Interpolation - this seems to mean that it will
      output samples at ~48 KHz? (~4:48)
    decim: '500'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
